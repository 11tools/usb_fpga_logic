# Keil uVision project bulkloop.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: bulkloop +hex
  AfterMake: c:\cypress\usb\bin\hex2bix -i -f 0xC2 -o bulkloop.iic bulkloop.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: fw.c bulkloop.c dscr.a51 twi.c EZUSB.LIB USBJmpTb.OBJ
